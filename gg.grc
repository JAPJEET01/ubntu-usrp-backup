options:
  parameters:
    author: army
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 384e3
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/army/Desktop/name.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: iridium_fft_burst_tagger_0
  id: iridium_fft_burst_tagger
  parameters:
    burst_post_len: '1000'
    burst_pre_len: '1000'
    burst_width: '100'
    center_frequency: '1626000000'
    debug: 'False'
    fft_size: '1024'
    history_size: '512'
    max_burst_len: '0'
    max_bursts: '0'
    sample_rate: '32999'
    threshold: '7'
  states: {}

connections:
- [blocks_file_source_0, '0', iridium_fft_burst_tagger_0, '0']
- [iridium_fft_burst_tagger_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
