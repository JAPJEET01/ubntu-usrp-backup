options:
  parameters:
    generate_options: qt_gui
    id: g
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '8'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: 384e3
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/army/Desktop/usrp project/received_data.iq
    repeat: 'True'
    type: complex
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', audio_sink_0, '0']
- [blocks_file_source_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
