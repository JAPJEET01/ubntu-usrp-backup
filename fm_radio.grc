options:
  parameters:
    generate_options: qt_gui
    id: fm_radio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ad
  id: variable
  parameters:
    value: int(sr//rfd)//48e3
  states: {}
- name: dev
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: inter
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rfd
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_1
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sr
  id: variable
  parameters:
    value: 1.92*10e6
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: 200e3
    stop: 108e6
    value: 98.3e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '50e-3'
    stop: '1'
    value: '300e-3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: int(ad)
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: sr/rfd
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: iridium_fft_burst_tagger_0
  id: iridium_fft_burst_tagger
  parameters:
    burst_post_len: '1000'
    burst_pre_len: '1000'
    burst_width: int(10e3)
    center_frequency: 98.3e6
    debug: 'False'
    fft_size: '1024'
    history_size: '512'
    max_burst_len: '10000'
    max_bursts: '10000'
    sample_rate: int(sr)
    threshold: '10'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '6000'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 500e3
    fc: tuning
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: rfd
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: 500e3
    center_freq0: tuning
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '50'
    samp_rate: sr
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [iridium_fft_burst_tagger_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', iridium_fft_burst_tagger_0, '0']
- [rational_resampler_xxx_0, '0', network_tcp_sink_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
